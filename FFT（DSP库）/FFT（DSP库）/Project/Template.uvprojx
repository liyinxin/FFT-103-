# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\User;..\Libraries\FWlib\inc;..\User\led;..\User\KEY;..\User\KEY-EXIT;..\User\USART1;..\User\ADC(DMA);..\User\ADC(DMA)-multichannel;..\User\SysTick_delay;..\User\TIM2;..\User\delay;..\Libraries\FWlib\src;..\User\ADC(DMA);..\User\SDS;..\User\lvbo;..\User\fft;..\DSP_LIB\Include;..\DSP_LIB;..\User\DSP_FFT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Lib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: stm32f10x_conf.h main.c stm32f10x_it.c stm32f10x_it.h
    ../User/KEY-EXIT/: EXTI_KEY.c
    ../User/led/: led.c
    ../User/delay/: delay.c
    ../User/USART1/: USART1.c
    ../User/ADC(DMA)/: adc.c
    ../User/TIM2/: TIME2.c
    ../User/DSP_FFT/: cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h cr4_fft_64_stm32.s
software components: CMSIS:CORE 5.0.1
